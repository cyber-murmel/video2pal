<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>short_sync_pulse</value></param>
<param><key>category</key><value>[PAL]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>max_nouts</key><value>1</value></param>
<param><key>title</key><value>PAL Short V Sync Pulse</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_short_low</value></param>
<param><key>comment</key><value>number of low
samples in short
sync pulse</value></param>
<param><key>value</key><value>int(2.35/32*samp_half_line)</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0.285</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0</value></param>
<param><key>comment</key><value>single short
sync pulse</value></param>
<param><key>lengths</key><value>samp_short_low, samp_half_line-samp_short_low</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>samp_half_line</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
<param><key>vlen</key><value>samp_half_line</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_half_line</value></param>
<param><key>label</key><value>Samples per Line</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>432</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
